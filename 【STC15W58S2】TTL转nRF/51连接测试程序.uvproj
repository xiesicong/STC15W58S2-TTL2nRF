# Keil uVision project 51连接测试程序.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 51连接测试程序 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: D:\Keil_v5\C51\INC\STC
  group Source Group 1
    ./: main.c uart.c
